# IAR project em35x.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: GENERATED_TOKEN_HEADER="app/builder/_replace_projectName_/_replace_tokenHeader_"; ZA_GENERATED_HEADER="app/builder/_replace_projectName_/_replace_projectName_.h"; _replace_bootloader_; BOARD_HEADER="_replace_boardHeader_"; PLATFORM_HEADER="_replace_halDirFromStackFs_/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3__replace_architectureIdUpperCase_; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/_replace_projectName_/_replace_projectName__endpoint_config.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ; ..\..\..\; ..\..\..\app\framework\include; _replace_stackDirFromProjBs_\; _replace_stackDirFromProjBs_\stack\; _replace_halDirFromProjBs_\; _replace_halDirFromProjBs_\..\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: GENERATED_TOKEN_HEADER="app/builder/_replace_projectName_/_replace_tokenHeader_"; ZA_GENERATED_HEADER="app/builder/_replace_projectName_/_replace_projectName_.h"; _replace_bootloader_; BOARD_HEADER="_replace_boardHeader_"; PLATFORM_HEADER="_replace_halDirFromStackFs_/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3__replace_architectureIdUpperCase_; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/_replace_projectName_/_replace_projectName__endpoint_config.h"
  AARM.AUserIncludes: $FILE_DIR$\; ; ..\..\..\; _replace_stackDirFromProjBs_\; _replace_stackDirFromProjBs_\stack\; _replace_halDirFromProjBs_\; _replace_halDirFromProjBs_\..\
  OBJCOPY.OOCOutputFile: _replace_projectName_.s37
  postbuild: $--projectName--$.bat $TARGET_BPATH$
  ILINK.IlinkOutputFile: _replace_projectName_.out
  ILINK.IlinkConfigDefines: _replace_bootloader_=1
  ILINK.IlinkIcfFile: _replace_halDirFromProjFs_/micro/cortexm3/em35x/_replace_architectureIdLowerCase_/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ./: call-command-handler.c callback-stub.c stack-handler-stub.c cli.c
    _replace_halDirFromProjFs_/micro/cortexm3/: adc.c button.c buzzer.c cstartup-iar-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep.c token-def.c token.c uart.c
    ../../../app/framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c print.c print-formatter.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c message.c multi-network.c util.c
    ../../../app/framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../../app/util/serial/: command-interpreter2.c serial.c
    _replace_halDirFromProjFs_/micro/generic/: crc.c endian.c sim-eeprom.c mem-util.c random.c
    _replace_halDirFromProjFs_/: ember-configuration.c
    ../../../app/util/common/: form-and-join-node-adapter.c form-and-join.c library.c
    ../../../build/hal-library-cortexm3-iar-_replace_architectureIdLowerCase_-em3xx/: hal-library.a
    ../../../build/sim-eeprom1-library-cortexm3-iar-_replace_architectureIdLowerCase_-em3xx/: sim-eeprom1-library.a
    ../../../app/framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../../app/util/security/: security-address-cache.c
    _replace_halDirFromProjFs_/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c
    _replace_halDirFromProjFs_/micro/cortexm3/usb/cdc/: callbacks.c
    ../../../app/util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
