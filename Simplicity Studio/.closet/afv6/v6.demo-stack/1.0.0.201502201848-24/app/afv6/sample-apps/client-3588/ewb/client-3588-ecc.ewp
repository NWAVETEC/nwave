# IAR project client-3588-ecc.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NULL_BTL; BOARD_HEADER="../../base/main/hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="../../base/main/hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3588; PHY_EM3XX; BOARD_DEV0680; CONFIGURATION_HEADER="app/afv6/sample-apps/client-3588/gen/afv6-config.h"; EMBER_ASSERT_SERIAL_PORT=1; EMBER_SERIAL1_BLOCKING; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=128; __SOURCEFILE__="$FILE_FNAME$"; EMBER_STACK_IP; APP_SERIAL=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..\..\; ..\..\..\..\..\stack\; ..\..\..\..\..\..\..\base\main\hal\; ..\..\..\..\..\..\..\base\main\hal\..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NULL_BTL; BOARD_HEADER="../../base/main/hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="../../base/main/hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3588; PHY_EM3XX; BOARD_DEV0680; CONFIGURATION_HEADER="app/afv6/sample-apps/client-3588/gen/afv6-config.h"; APP_SERIAL=1; EMBER_ASSERT_SERIAL_PORT=1; EMBER_SERIAL1_BLOCKING; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=128; EMBER_STACK_IP
  AARM.AUserIncludes: $FILE_DIR$\; ..\..\..\..\..\; ..\..\..\..\..\stack\; ..\..\..\..\..\..\..\base\main\hal\..\
  OBJCOPY.OOCOutputFile: client-3588-ecc.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: client-3588-ecc.out
  ILINK.IlinkConfigDefines: NULL_BTL=1
  ILINK.IlinkIcfFile: ../../../../../../../base/main/hal/micro/cortexm3/em35x/em3588/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../gen/: afv6-uri-mapper.c afv6-callback-stubs.c afv6-events.c afv6-uri-mapper.c afv6-exi-api.c afv6-events.c afv6-callback-stubs.c afv6-callbacks.c
    ../../../../../../../base/main/hal/micro/cortexm3/: adc.c bootloader-interface-app.c bootloader-interface-standalone.c bootloader-interface.c cstartup-iar-common.c diagnostic.c faults.s79 isr-stubs.s79 mfg-token.c micro-common.c micro.c sleep.c token-def.c token.c uart.c
    ../../../../../../../base/main/hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../../../../../base/main/hal/micro/cortexm3/em35x/em3588/: mpu.c
    ../../../../../../../base/main/hal/: ember-base-configuration.c
    ../../../../../stack/config/: ember-ip-configuration.c
    ../../../../../app/util/serial/: serial.c serial-printf.c
    ../../../../../build/zigbee-ip-ecc-stack-cortexm3-iar-em3588-em3xx/: zigbee-ip-ecc-stack.a zigbee-ip-ecc-stack.a
    ../../../../../build/ip-ecc-library-internal-cortexm3-iar-em3588-em3xx/: ip-ecc-library-internal.a
    ../../../../../build/hal-library-cortexm3-iar-em3588-em3xx/: hal-library.a
    ../../../../../build/afv6-library-cortexm3-iar-em3588-em3xx/: afv6-library.a
    ../../../plugin/billing-client/: billing-client.c
    ../../../plugin/cli/: cli.c
    ../../../plugin/client/: client.c
    ../../../plugin/common/: common.c main.c uri-handler.c scheduled-object.c list.c end-device.c action-handler.c ecc-certificate.c dynamic-uri-handler-lookup.c scratchpad.c uri-parser.c
    ../../../plugin/debug-print/: print.c
    ../../../plugin/der-client/: der-client.c
    ../../../plugin/drlc-client/: drlc-client.c
    ../../../plugin/drlc-common/: drlc-common.c end-device-control.c
    ../../../plugin/exi/: exi-plugin.c exi-utilities.c
    ../../../plugin/function-set-assignments-client/: function-set-assignments-client.c
    ../../../plugin/http/: http-plugin.c
    ../../../plugin/log-event-client/: log-event-client.c
    ../../../plugin/log-event-common/: log-event-common.c
    ../../../plugin/messaging-client/: messaging-client.c
    ../../../plugin/messaging-common/: text-message.c
    ../../../plugin/metering-client/: metering-client.c
    ../../../plugin/metering-common/: reading.c
    ../../../plugin/netstat-client/: netstat-client.c
    ../../../plugin/netstat-server/: netstat-server.c counters.c
    ../../../plugin/power-status-client/: power-status-client.c
    ../../../plugin/power-status-common/: power-status-common.c
    ../../../plugin/prepayment-client/: prepayment-client.c
    ../../../plugin/pricing-client/: pricing-client.c
    ../../../plugin/software-download-client/: software-download-client.c
    ../../../plugin/subscription-client/: subscription-client.c
    ../../../plugin/time-client/: time-client.c
