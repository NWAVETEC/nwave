# IAR project test.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NULL_BTL; BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM357; PHY_EM3XX; BOARD_DEV0680; CONFIGURATION_HEADER="app/afv6/sample-apps/test/gen/afv6-config.h"; APP_SERIAL=1; EMBER_ASSERT_SERIAL_PORT=1; EMBER_SERIAL1_BLOCKING; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=128; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..\..\; ..\..\..\..\..\STACK\; ..\..\..\..\..\HAL\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM357; PHY_EM3XX; BOARD_DEV0680; CONFIGURATION_HEADER="app/afv6/sample-apps/test/gen/afv6-config.h"; APP_SERIAL=1; EMBER_ASSERT_SERIAL_PORT=1; EMBER_SERIAL1_BLOCKING; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=128
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: test.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkIcfFile: ../../../../../hal/micro/cortexm3/em35x/em357/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../../../hal/micro/cortexm3/: adc.c bootloader-interface-app.c bootloader-interface-standalone.c bootloader-interface.c button.c buzzer.c cstartup-iar-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c sleep.c token-def.c token.c uart.c
    ../gen/: afv6-uri-mapper.c afv6-callback-stubs.c afv6-events.c afv6-uri-mapper.c afv6-exi-api.c afv6-exi-api-test.c afv6-events.c afv6-callback-stubs.c
    ../../../../../hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../../../build/hal-library-cortexm3-iar-em357-em3xx/: hal-library.a
    ../../../../../hal/micro/cortexm3/em35x/: mpu.c
    ../../../../../app/util/serial/: serial.c
    ../../../../../app/afv6/core/: print.c
    ../../../../../build/zigbee-ip-psk-stack-cortexm3-iar-em357-em3xx/: zigbee-ip-psk-stack.a
    ../../../../../build/afv6-library-cortexm3-iar-em357-em3xx/: afv6-library.a
    ../../../../../build/afv6-esi-library-cortexm3-iar-em357-em3xx/: afv6-esi-library.a
    ../../../plugin/client/: client.c
    ../../../plugin/common/: common.c main.c uri-handler.c scheduled-object.c
    ../../../plugin/drlc-client/: drlc-client.c
    ../../../plugin/drlc-common/: drlc-common.c end-device-control.c
    ../../../plugin/drlc-server/: drlc-server.c
    ../../../plugin/end-device/: end-device.c
    ../../../plugin/exi/: exi-plugin.c exi-utilities.c
    ../../../plugin/http/: http-plugin.c
    ../../../plugin/list/: list.c
    ../../../plugin/messaging-client/: messaging-client.c
    ../../../plugin/server/: server.c
    ../../../plugin/smart-plug/: smart-plug.c
    ../../../plugin/subscription-client/: subscription-client.c
    ../../../plugin/subscription-server/: subscription-server.c
    ../../../plugin/test/: test-plugin.c
    ../../../plugin/time-client/: time-client.c
    ../../../plugin/time-server/: time-server.c
