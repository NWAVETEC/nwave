# IAR project afv6.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NULL_BTL; BOARD_HEADER="_replace_halDirFromStackFs_/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="_replace_halDirFromStackFs_/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM_replace_chipNumber_; PHY_EM3XX; BOARD_DEV0680; CONFIGURATION_HEADER="_replace_generatedHeader_"; EMBER_ASSERT_SERIAL_PORT=1; EMBER_SERIAL1_BLOCKING; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=128; __SOURCEFILE__="$FILE_FNAME$"; EMBER_STACK_IP
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; _replace_stackDirFromProjBs_\; _replace_stackDirFromProjBs_\stack\; _replace_halDirFromProjBs_\; _replace_halDirFromProjBs_\..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NULL_BTL; BOARD_HEADER="_replace_halDirFromStackFs_/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="_replace_halDirFromStackFs_/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM_replace_chipNumber_; PHY_EM3XX; BOARD_DEV0680; CONFIGURATION_HEADER="_replace_generatedHeader_"; APP_SERIAL=1; EMBER_ASSERT_SERIAL_PORT=1; EMBER_SERIAL1_BLOCKING; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=128; EMBER_STACK_IP
  AARM.AUserIncludes: $FILE_DIR$\; _replace_stackDirFromProjBs_\; _replace_stackDirFromProjBs_\stack\; _replace_halDirFromProjBs_\..\
  OBJCOPY.OOCOutputFile: _replace_deviceName_.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: _replace_deviceName_.out
  ILINK.IlinkConfigDefines: NULL_BTL=1
  ILINK.IlinkIcfFile: _replace_halDirFromProjFs_/micro/cortexm3/em35x/em_replace_chipNumber_/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    _replace_genDir_/: afv6-uri-mapper.c afv6-callback-stubs.c afv6-events.c
    _replace_halDirFromProjBs_/micro/cortexm3/: adc.c bootloader-interface-app.c bootloader-interface-standalone.c bootloader-interface.c cstartup-iar-common.c diagnostic.c faults.s79 isr-stubs.s79 mfg-token.c micro-common.c micro.c sleep.c token-def.c token.c uart.c
    _replace_halDirFromProjBs_/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    _replace_halDirFromProjBs_/micro/cortexm3/em35x/em_replace_chipNumber_/: mpu.c
    _replace_halDirFromProjBs_/: ember-base-configuration.c
    _replace_stackDirFromProjBs_/stack/config/: ember-ip-configuration.c
    _replace_stackDirFromProjBs_/app/util/serial/: serial.c serial-printf.c
